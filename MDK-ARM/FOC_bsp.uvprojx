# Keil uVision project FOC_bsp.uvprojx, settings and files
target FOC_bsp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FOC_bsp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;..\Core\Inc;..\FOC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: gpio.c main.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group CMSIS-DSP
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FOC
    ../FOC/: foc_app.h foc_app.c foc_test.h foc_test.c foc_sin_table.c foc_uart.h foc_uart.c foc_as5048a.c foc_as5048a.h foc_config.h FOC_CONTEXT.md foc_gimbal.c foc_gimbal.h foc_hw.c foc_hw.h foc_math.c foc_math.h foc_motor.c foc_motor.h foc_pid.c foc_pid.h foc_pwm.c foc_pwm.h foc_type.h
software components: CMSIS:CORE 4.3.0
